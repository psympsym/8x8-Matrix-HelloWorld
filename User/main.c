/*-------------------------------------------------------------------
/*      (C) Copyright 2023, PSYM. All Rights Reserved 
/*-------------------------------------------------------------------
/* File name   : main.c
/* Description : 
/* Author      : PSYM
/*-------------------------------------------------------------------
/* Update note:
/* -----------   -----------   --------------------------------------
/*    Date         Author                       Note
/* -----------   -----------   --------------------------------------
/* 2023-05-23,     psym
/*   16:48
**/

/* 包含头文件 -------------------------------------------------------*/
#include "main.h"
#include "STC8Ax_DELAY.h"
#include "STC8Ax_REG.h"

/* 私有类型定义 -----------------------------------------------------*/
/* None. */

/* 私有宏定义 -------------------------------------------------------*/
/* None. */

/* 私有变量 ---------------------------------------------------------*/
/* None. */

/* 扩展变量 ---------------------------------------------------------*/
/* None. */

/* 私有函数原形 -----------------------------------------------------*/
/* None. */

/* 函数体 -----------------------------------------------------------*/
/*
 * 功能: 
 * 参数: None
 * 返回: None
 * 说明: None
 */
void main()
{
	uint8 i = 0;
	uint8 j = 0;
    System_Init();
    //Peripheral_Init();
    while (1)
    {
        for (i = 0; i < IMAGES_LEN; i++)
        {
            for (j = 0; j < 25; j++)
            {
                LED(i);
            }
        }

		for (i = 0; i < IMAGES1_LEN; i++)
        {
            for (j = 0; j < 50; j++)
            {
                LED1(i);
            }
			P7 = 0x00;
			Delay_ms(50);
        }
    }
}
/*>>>>>>>>>> (C) COPYRIGHT PSYM <<<<<< >>>>>> END OF FILE <<<<<<<<<<*/
